# Keil uVision project zlgGUI.uvproj, settings and files
target zlgGUI (ARM-ADS)
  device: LM3S8962 Texas Instruments
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: zlgGUI +hex
  c flags: Optim=3 oTime=1
  c include: ..\..\Source\LM3S_Lib\inc;..\..\Source\ZLG_GUI;..\..\Source\HAL\Oled\Head;..\..\Source\App
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application
    ../../Source/App/: main.c
  group HAL
    ../../Source/HAL/Oled/Src/: lcmdrv.c rit128x96x4.c
    ../../Source/HAL/: startup_rvmdk.S
  group zlgGUI
    ../../Source/ZLG_GUI/: ConvertColor.c FONT5_7.c FONT8_8.c FONT24_32.c GUI_BASIC.c GUI_StockC.c loadbit.c menu.c spline.c windows.c
  group LM3S_Drv_Lib
    ../../Source/LM3S_Lib/DriverLib/: driverlib.lib
